# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Timer.c Timer.h Delay.c Delay.h LED.c LED.h TrafficLights.c TrafficLights.h Nixie.c Nixie.h Key.c Key.h
